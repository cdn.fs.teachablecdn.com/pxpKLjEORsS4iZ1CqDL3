FUNCTION_BLOCK DigitalInputChannel IMPLEMENTS I_DigitalInput
VAR
	input AT %I* : BOOL;
END_VAR

PROPERTY PUBLIC State : BOOL
GET
State := input;
END_GET
END_PROPERTY

END_FUNCTION_BLOCK
