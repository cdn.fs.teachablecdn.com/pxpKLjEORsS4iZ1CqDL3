INTERFACE I_DigitalInput

PROPERTY PUBLIC State : BOOL
GET
END_GET
END_PROPERTY

END_INTERFACE
