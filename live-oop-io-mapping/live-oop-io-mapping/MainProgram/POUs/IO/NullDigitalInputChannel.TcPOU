FUNCTION_BLOCK NullDigitalInputChannel implements I_DigitalInput

PROPERTY PUBLIC State : BOOL
GET
State := FALSE;
END_GET
END_PROPERTY

END_FUNCTION_BLOCK
